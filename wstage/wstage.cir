* /home/drako/eSim-Workspace/wstage/wstage.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: Tue Jun 29 22:16:41 2021

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
x15  Net-_U1-Pad24_ Net-_U1-Pad22_ Net-_x15-Pad3_ and_gate
x13  Net-_U1-Pad24_ Net-_U1-Pad19_ Net-_x13-Pad3_ and_gate
U1  Net-_U1-Pad1_ Net-_U1-Pad2_ Net-_U1-Pad3_ Net-_U1-Pad4_ Net-_U1-Pad5_ Net-_U1-Pad6_ Net-_U1-Pad7_ Net-_U1-Pad8_ Net-_U1-Pad9_ Net-_U1-Pad10_ Net-_U1-Pad11_ Net-_U1-Pad12_ Net-_U1-Pad13_ Net-_U1-Pad14_ Net-_U1-Pad15_ Net-_U1-Pad16_ Net-_U1-Pad17_ Net-_U1-Pad18_ Net-_U1-Pad19_ Net-_U1-Pad20_ Net-_U1-Pad21_ Net-_U1-Pad22_ Net-_U1-Pad23_ Net-_U1-Pad24_ PORT
x16  Net-_x15-Pad3_ Net-_U1-Pad21_ Net-_U1-Pad23_ Net-_x14-Pad3_ halfadder
x14  Net-_x13-Pad3_ Net-_U1-Pad18_ Net-_x14-Pad3_ Net-_U1-Pad20_ Net-_x12-Pad3_ fulladder
x11  Net-_U1-Pad24_ Net-_U1-Pad16_ Net-_x11-Pad3_ and_gate
x12  Net-_x11-Pad3_ Net-_U1-Pad15_ Net-_x12-Pad3_ Net-_U1-Pad17_ Net-_x10-Pad3_ fulladder
x9  Net-_U1-Pad24_ Net-_U1-Pad13_ Net-_x10-Pad1_ and_gate
x10  Net-_x10-Pad1_ Net-_U1-Pad12_ Net-_x10-Pad3_ Net-_U1-Pad14_ Net-_x10-Pad5_ fulladder
x7  Net-_U1-Pad24_ Net-_U1-Pad10_ Net-_x7-Pad3_ and_gate
x8  Net-_x7-Pad3_ Net-_U1-Pad9_ Net-_x10-Pad5_ Net-_U1-Pad11_ Net-_x6-Pad3_ fulladder
x5  Net-_U1-Pad24_ Net-_U1-Pad7_ Net-_x5-Pad3_ and_gate
x6  Net-_x5-Pad3_ Net-_U1-Pad6_ Net-_x6-Pad3_ Net-_U1-Pad8_ Net-_x4-Pad3_ fulladder
x3  Net-_U1-Pad24_ Net-_U1-Pad4_ Net-_x3-Pad3_ and_gate
x4  Net-_x3-Pad3_ Net-_U1-Pad3_ Net-_x4-Pad3_ Net-_U1-Pad5_ Net-_x2-Pad1_ fulladder
x1  Net-_U1-Pad24_ Net-_U1-Pad1_ Net-_x1-Pad3_ and_gate
x2  Net-_x2-Pad1_ Net-_x1-Pad3_ Net-_U1-Pad2_ ? halfadder

.end
